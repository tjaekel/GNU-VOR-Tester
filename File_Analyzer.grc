options:
  parameters:
    author: Torsten Jaekel
    copyright: free
    description: demodulate VOR recording file
    generate_options: qt_gui
    id: File_Anaylzer
    output_language: python
    title: File_Analyzer
  states: {}

blocks:
- name: am_demod_lowpass_cutoff
  id: variable
  parameters:
    value: '500'
  states: {}
- name: am_demod_lowpass_width
  id: variable
  parameters:
    value: '400'
  states: {}
- name: fm_demod_samp_rate
  id: variable
  parameters:
    value: 2**12
  states: {}
- name: fm_lowpass_cutoff
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: fm_lowpass_width
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: fm_ref_deviation
  id: variable
  parameters:
    value: '480'
  states: {}
- name: fm_ref_freq
  id: variable
  parameters:
    value: '9960'
  states: {}
- name: ident_freq
  id: variable
  parameters:
    value: '1020'
  states: {}
- name: input_samp_rate
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tone_bandpass_width
  id: variable
  parameters:
    value: '5'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '30'
  states: {}
- name: tone_samp_rate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1'
    max_gain: '65536'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc2_xx_0_0_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: float
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: tone_freq - 5
    audio_stop: tone_freq * 2
    chan_rate: input_samp_rate
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: fm_demod_samp_rate // tone_samp_rate
    audio_pass: tone_freq - 5
    audio_stop: tone_freq * 2
    chan_rate: fm_demod_samp_rate
    deviation: fm_ref_deviation
    gain: '1.0'
    tau: '0.0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: input_samp_rate // tone_samp_rate
    gain: '800'
    high_cutoff_freq: tone_freq + tone_bandpass_width
    low_cutoff_freq: tone_freq - tone_bandpass_width
    samp_rate: input_samp_rate
    type: fir_filter_fff
    width: tone_bandpass_width
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: tone_freq + tone_bandpass_width
    low_cutoff_freq: tone_freq - tone_bandpass_width
    samp_rate: tone_samp_rate
    type: fir_filter_fff
    width: tone_bandpass_width
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\tj\Documents\GNURadio\ELB_VOR_2MSPS.complex
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '16'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fm_ref_freq
    decim: input_samp_rate // fm_demod_samp_rate
    samp_rate: input_samp_rate
    taps: firdes.low_pass(1000, input_samp_rate, fm_lowpass_cutoff, fm_lowpass_width)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1020'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate/40
    type: fir_filter_ccf
    width: '1029'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '2'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: am_demod_lowpass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: input_samp_rate
    type: fir_filter_ccf
    width: am_demod_lowpass_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '11000'
    decim: '40'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '11000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: Signals_30Hz
    nconnections: '2'
    size: '1024'
    srate: '500'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/40
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: ccc
  states: {}
- name: utility
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import math

      def hz_to_rad_per_sample(f_hz, sample_rate):
          return f_hz * ((2 * math.pi) / sample_rate)
  states: {}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_1, '0']
- [analog_agc2_xx_0_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [analog_agc2_xx_0_0_1, '0', blocks_multiply_const_vxx_1, '0']
- [analog_am_demod_cf_0, '0', band_pass_filter_0_0, '0']
- [analog_fm_demod_cf_0, '0', band_pass_filter_0_0_0, '0']
- [band_pass_filter_0_0, '0', dc_blocker_xx_0_0, '0']
- [band_pass_filter_0_0_0, '0', dc_blocker_xx_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', low_pass_filter_0_1, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_throttle2_0, '0', analog_agc2_xx_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0_0, '0', analog_agc2_xx_0_0_1, '0']
- [dc_blocker_xx_1, '0', analog_agc2_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_1, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_1, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
