options:
  parameters:
    author: Torsten Jaekel
    copyright: free
    description: demodulate VOR recording file
    generate_options: qt_gui
    id: File_Anaylzer
    output_language: python
    title: File_Analyzer
  states: {}

blocks:
- name: DELAY
  id: variable_qtgui_dial_control
  parameters:
    label: offset
    maximum: '360'
    minimum: '0'
    showvalue: 'True'
    type: int
    value: '0'
  states: {}
- name: am_demod_lowpass_cutoff
  id: variable
  parameters:
    value: '500'
  states: {}
- name: am_demod_lowpass_width
  id: variable
  parameters:
    value: '400'
  states: {}
- name: fm_demod_samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: fm_lowpass_cutoff
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: fm_lowpass_width
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: fm_ref_deviation
  id: variable
  parameters:
    value: '480'
  states: {}
- name: fm_ref_freq
  id: variable
  parameters:
    value: '9960'
  states: {}
- name: ident_freq
  id: variable
  parameters:
    value: '1020'
  states: {}
- name: input_samp_rate
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tone_bandpass_width
  id: variable
  parameters:
    value: '5'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '30'
  states: {}
- name: tone_samp_rate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: '0 = FROM 360 = TO : '
    type: int
    value: DELAY
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    comment: |-
      automatic gain control
      for entire signal
      (deal with weak signal recorded)
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    comment: normalize our 30 Hz signal
    decay_rate: '1e-2'
    gain: '1'
    max_gain: '65536'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc2_xx_0_0_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    comment: normalize our 30 Hz signal
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: float
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: tone_freq - 10
    audio_stop: tone_freq + 10
    chan_rate: input_samp_rate
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    comment: convert into radial range (for PI values)
    const: math.pi * 1000
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    comment: trim needle offset error
    const: '0'
    type: float
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: fm_demod_samp_rate // tone_samp_rate
    audio_pass: tone_freq - 10
    audio_stop: tone_freq + 10
    chan_rate: fm_demod_samp_rate
    deviation: fm_ref_deviation
    gain: '1.0'
    tau: '0.0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: listen to the Morse Code
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    comment: get the 30 Hz signal as AM modulated
    decim: input_samp_rate // tone_samp_rate
    gain: '800'
    high_cutoff_freq: tone_freq + tone_bandpass_width
    low_cutoff_freq: tone_freq - tone_bandpass_width
    samp_rate: input_samp_rate
    type: fir_filter_fff
    width: tone_bandpass_width
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    comment: get the other 30 Hz signal, here from FM
    decim: '1'
    gain: '1'
    high_cutoff_freq: tone_freq + tone_bandpass_width
    low_cutoff_freq: tone_freq - tone_bandpass_width
    samp_rate: tone_samp_rate
    type: fir_filter_fff
    width: tone_bandpass_width
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    comment: |-
      get the pase difference,
      from Q component
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      trim for GRC delay and
      correct VOR variation
      (location on recording)
    delay: '170'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: |-
      variable delay to show "effect"
      and as TO / FROM selection
    delay: int((DELAY * 420) / 360)
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\tj\Documents\GNURadio\generatedVOR_2M.rec
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      filter and average the sample
      to remove a jittering phase
    length: '1000'
    max_iter: '2'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: convert from radial to degree
    const: '360'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      do the phase comparison,
      with IQ-like demodulator approach
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: needed when replaying files
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: remove the low 30 Hz and any DC offset
    length: '16'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fm_ref_freq
    comment: |-
      needed to shift down the 9960 KHz to zero,
      before we can do FM Demod
    decim: input_samp_rate // fm_demod_samp_rate
    samp_rate: input_samp_rate
    taps: firdes.low_pass(1000, input_samp_rate, fm_lowpass_cutoff, fm_lowpass_width)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1020'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate/40
    type: fir_filter_ccf
    width: '1029'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      any Rational Resampler needs
      actually a filter (remove created aliases)
    cutoff_freq: '1000'
    decim: '1'
    gain: '2'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: am_demod_lowpass_cutoff
    decim: '1'
    gain: '1'
    samp_rate: input_samp_rate
    type: fir_filter_ccf
    width: am_demod_lowpass_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      remote all not needed "noise"
      (outside spectrum)
    cutoff_freq: '11000'
    decim: '40'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '11000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '11000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/80
    type: fir_filter_ccf
    width: '11000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_compass_0_0
  id: qtgui_compass
  parameters:
    comment: |-
      adjust OBS knob for
      minimal deviation!
    fullNeedle: '1'
    min_size: '100'
    name: OBS Needle
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Reference
    label2: Variable
    name: Signals_30Hz
    nconnections: '2'
    size: 500 // 4
    srate: '500 '
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: PhaseDiff
    size: '1024'
    srate: '500'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/40
    comment: |-
      display the signal spectrum
      we are processing
    fc: '0'
    fftsize: '1024'
    name: Spectrum
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      convert into 48 KHz sampling rate
      for audio sink
    decim: '50'
    interp: '48'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      reduce sampling rate:
      our AM and FM Demod cannot
      take a fast sample rate
    decim: '2'
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: reference
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: variable
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: reference
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: variable
  states: {}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_1, '0']
- [analog_agc2_xx_0_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [analog_agc2_xx_0_0, '0', virtual_sink_0_0, '0']
- [analog_agc2_xx_0_0_1, '0', blocks_multiply_const_vxx_1, '0']
- [analog_am_demod_cf_0, '0', band_pass_filter_0_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_sub_xx_0, '1']
- [analog_fm_demod_cf_0, '0', band_pass_filter_0_0_0, '0']
- [band_pass_filter_0_0, '0', dc_blocker_xx_0_0, '0']
- [band_pass_filter_0_0_0, '0', dc_blocker_xx_1, '0']
- [blocks_complex_to_arg_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', low_pass_filter_0_1, '0']
- [blocks_delay_0_0, '0', blocks_delay_0, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_sub_xx_0, '0', qtgui_compass_0_0, '0']
- [blocks_throttle2_0, '0', analog_agc2_xx_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0_0, '0', analog_agc2_xx_0_0_1, '0']
- [dc_blocker_xx_1, '0', analog_agc2_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_1, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_1, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_1_0, '0', blocks_delay_0_0, '0']
- [low_pass_filter_1_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_1_0, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0_0, '0', blocks_float_to_complex_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
