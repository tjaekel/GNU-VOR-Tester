options:
  parameters:
    author: Torsten Jaekel
    description: receive and listen to a FM sound broadcast station
    generate_options: qt_gui
    id: RTL_SDR_WBFM_decoder
    output_language: python
    title: RTL_SDR_WBFM_decoder
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 95.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '200000.0'
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: '200000.0'
    freq0: 95.5e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
