options:
  parameters:
    generate_options: qt_gui
    id: RTL_SDR_recorder
    output_language: python
    title: RTL_SDR_recorder
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 95.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: FM_rec_95_5MHz
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '200000.0'
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: '200000.0'
    freq0: 95.5e6
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
