options:
  parameters:
    generate_options: qt_gui
    id: VOR_playFile
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: DELAY
  id: variable_qtgui_range
  parameters:
    label: trim_DELAY
    start: '0'
    step: samp_rate//10000
    stop: samp_rate//4
    value: '866'
  states: {}
- name: FFTsize
  id: variable
  parameters:
    value: 2**9
  states: {}
- name: OBS_DELAY
  id: variable_qtgui_dial_control
  parameters:
    comment: Trim for minimal deviation 0 (on compass)
    label: OBS
    maximum: '180'
    minimum: '0'
    minsize: '250'
    showvalue: 'True'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1024*32
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '30'
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '2.36'
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '20'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate/1)
    max_dev: '480'
    quad_rate: int(samp_rate/1)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: morse code to soundcard
    samp_rate: '48000'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: trim for correct phase offset, e.g. 0 degree
    delay: DELAY
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: trim for correct phase offset, e.g. 0 degree
    delay: int(round(((OBS_DELAY * samp_rate) // 1) // (360 * 32)))
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\tj\Documents\GNURadio\generatedVOR.rec
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: FFTsize
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: FFTsize
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.25'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: here is something missing, e.g. the UNIT_CIRCLE!
    const: 180 / math.pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '90'
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: get the 30 Hz Bin from spectrum
    num_items: tone_freq
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    comment: get the 30 Hz Bin from spectrum
    num_items: tone_freq
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: FFTsize
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: FFTsize
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: normalize for scope
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    comment: normalize for scope
    type: float
  states: {}
- name: blocks_sub_xx_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_1_0
  id: blocks_sub_xx
  parameters:
    comment: 'ALTERNATIVE: adjust OBS knob to trim for direction'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: FFTsize
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: FFTsize
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: FFTsize
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(FFTsize)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: FFTsize
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(FFTsize)
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: separate the Morse Code
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '3'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '4000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '1'
    gain: '3.73'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '60'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '12000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '60'
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '30'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: This path is NOT really correct (not a stable value as result)! UNIT_CIRCLE needed?!
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'Alternative: compare both 30 Hz via substract (needs normalization!)'
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    comment: adjust OBS knob for minimal deviation!
    fullNeedle: '1'
    min_size: '100'
    name: OBS Needle
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Radial
    max: '360'
    min: '0'
    name: ''
    type: float
    unit1: degrees
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: Morse Code
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: 30 Hz Frequencies
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: upsample by 1.5, from 32768k SR to 48K audio rate
    decim: '2'
    interp: '3'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: decimate (sample rate down) for smaller FFT
    decim: '64'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: decimate (sample rate down) for smaller FFT
    decim: '64'
    interp: '1'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: variable
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: reference
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: reference
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: reference
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: variable
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: variable
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_1_0, '0', blocks_sub_xx_0_0, '1']
- [analog_nbfm_rx_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_abs_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_complex_to_arg_0, '0', blocks_sub_xx_0_1, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0_1, '1']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_real_0_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_compass_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0_0, '0', virtual_sink_0, '0']
- [blocks_sub_xx_0_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_sub_xx_0_1_0, '0', blocks_abs_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', dc_blocker_xx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_skiphead_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_skiphead_0_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_0_0_0, '0']
- [dc_blocker_xx_0_0, '0', high_pass_filter_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [high_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_stream_to_vector_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0_0, '0']
- [virtual_source_0_0, '0', blocks_sub_xx_0_1_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_0_0_0, '0']
- [virtual_source_1_0, '0', blocks_sub_xx_0_1_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
