options:
  parameters:
    generate_options: qt_gui
    id: VOR_playFile
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: DELAY
  id: variable_qtgui_range
  parameters:
    label: trim_DELAY
    start: '0'
    step: samp_rate//10000
    stop: samp_rate//4
    value: '866'
  states: {}
- name: FFTsize
  id: variable
  parameters:
    value: 2**9
  states: {}
- name: OBS_DELAY
  id: variable_qtgui_dial_control
  parameters:
    comment: Trim for minimal deviation 0 (on compass)
    label: OBS
    maximum: '180'
    minimum: '0'
    minsize: '250'
    showvalue: 'True'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1024*32
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '30'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '48240'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '-1.4'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate/1)
    max_dev: '480'
    quad_rate: int(samp_rate/1)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: morse code to soundcard
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: trim for correct phase offset, e.g. 0 degree
    delay: DELAY
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: trim for correct phase offset, e.g. 0 degree
    delay: int(round(((OBS_DELAY * samp_rate) // 1) // (360 * 32)))
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\tj\Documents\GNURadio\RBT_VOR_Sample_32768kHz.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: samp_rate // 2
    max_iter: '1'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '180'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: normalize for scope
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    comment: normalize for scope
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '64'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '64'
    long_form: 'True'
    type: cc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: separate the Morse Code
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '3'
    samp_rate: (samp_rate * 3) / 2
    type: fir_filter_ccf
    width: '4000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '30'
    decim: '1'
    gain: '3.73'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '30'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '9960'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '9960'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '30'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '30'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_compass_0_0
  id: qtgui_compass
  parameters:
    comment: adjust OBS knob for minimal deviation!
    fullNeedle: '1'
    min_size: '100'
    name: OBS Needle
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: Morse Code
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: 30 Hz Frequencies
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: upsample by 1.5, from 32768k SR to 48K audio rate
    decim: '2'
    interp: '3'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: variable
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: reference
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: reference
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: variable
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_delay_0, '0']
- [analog_agc2_xx_0, '0', dc_blocker_xx_0_0, '0']
- [analog_agc2_xx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_1_0, '0', blocks_sub_xx_0_0, '1']
- [analog_nbfm_rx_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_complex_to_arg_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_real_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_compass_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0, '0', analog_agc2_xx_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_0_0_0, '0']
- [dc_blocker_xx_0_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [high_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_1, '0', blocks_float_to_complex_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
